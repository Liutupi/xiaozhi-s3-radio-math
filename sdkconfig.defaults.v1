## sdkconfig.defaults.v1
```kconfig
CONFIG_BOARD_TYPE_BREAD_COMPACT_WIFI_LCD=y
CONFIG_LCD_ST7735_128X160=y
CONFIG_LANGUAGE_ZH_CN=y
```
